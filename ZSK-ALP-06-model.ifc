Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:19:22+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-ALP-06
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Комплекс скалолазный, ZSK-ALP-06 Скалодром «Башни с мостом»
In: Площадка
Description: Комплекс скалолазный. Скалодром «Башни с мостом»; Classification: 59.1.15.01-0911 Стенка для лазания (Классификатор строительных ресурсов (КСР)); Material: стеклопластик на стальном каркасе, сталь с антикоррозийным п
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-ALP-06; ModelReference: Скалодром «Башни с мостом»; ProductionYear: 2026; ArticleNumber: ZSK-ALP-06
ORION_Изделие - Артикул: ZSK-ALP-06; Артикул прежний: SD-ALP-06; Наименование: Скалодром «Башни с мостом»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 3200 × 1200 × 2300 мм; Возраст: от 8 лет; Материал: стеклопластик на стальном каркасе, сталь с антикоррозийным покрытием, нержавеющий крепёж; Цена: 510 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/climbing/30905; Код КСИ: CPr>EDB250; Класс КСИ: Стенка для лазания; Коды КСР: 59.1.15.01-0911 … 59.1.15.01-0911
ADSK - ADSK_Наименование: Скалодром «Башни с мостом»; ADSK_Марка: ZSK-ALP-06; ADSK_Код изделия: 59.1.15.01-0911; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: стеклопластик на стальном каркасе, сталь с антикоррозийным покрытием, нержавеющий крепёж; ADSK_URL страницы изделия: https://зск.рф/catalog/climbing/30905
ZSK_Благоустройство - ZSK_Возрастная_группа: от 8 лет; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB250; ZSK_Артикул_прежний: SD-ALP-06
Qto_ORION - Длина: 3200 mm; Ширина: 1200 mm; Высота: 2300 mm
